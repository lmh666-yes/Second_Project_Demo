# Keil uVision project 000标准模板库.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 000标准模板库 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000, SYS_TEST_BOARD=2
  c include: .\FWLIB\inc;.\FreeRTOS\inc;.\FreeRTOS\port;.\ETH\inc;.\ETH\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --muldefweak --diag_suppress=L6439W
  group user
    ./: main.c
  group FWLIB/src
    ./FWLIB/src//: gpio_core.c delay.c led.c key.c beep.c ext_io.c lcd.c xpt2046.c mpu6050.c sys_bh1750.c sys_bmp280.c sys_ccs811.c vl53l0x.c oled.c ds18b20.c dht11.c w25qxx.c w25qxx_log.c at24c02.c sys_rs485.c sys_frame.c modbus.c esp8266.c mqtt.c hcsr04.c pid.c kalman.c sys_filter.c sys_encoder.c sys_clock.c sys_tick.c sys_softimer.c sys_usart.c sys_ind.c lora_e22.c sys_str.c sys_tim.c sys_exti.c sys_nvic.c sys_dma.c sys_eth.c sys_fault.c sys_flash.c sys_i2c.c sys_spi.c sys_adc.c sys_dac.c sys_can.c sys_wdg.c sys_pwr.c sys_rtc.c sram.c uln2003.c tb6612.c rgb5x5.c ntc_pt100.c
  group FWLIB/inc
    ./FWLIB/inc//: gpio_core.h delay.h sys_bitband.h led.h key.h beep.h ext_io.h lcd.h lcd_font.h xpt2046.h mpu6050.h sys_bh1750.h sys_bmp280.h sys_ccs811.h vl53l0x.h oled.h ds18b20.h dht11.h w25qxx.h w25qxx_log.h at24c02.h sys_rs485.h sys_frame.h modbus.h esp8266.h mqtt.h hcsr04.h pid.h kalman.h sys_filter.h sys_encoder.h sys_clock.h sys_tick.h sys_softimer.h sys_usart.h lora_e22.h sys_str.h sys_tim.h sys_exti.h sys_nvic.h sys_dma.h sys_eth.h sys_fault.h sys_flash.h sys_i2c.h sys_spi.h sys_adc.h sys_dac.h sys_can.h sys_wdg.h sys_pwr.h sys_rtc.h sram.h uln2003.h tb6612.h rgb5x5.h ntc_pt100.h
  group ETH/src
    ./ETH/src/: stm32f4x7_eth.c
  group ETH/inc
    ./ETH/inc/: stm32f4x7_eth.h
  group ETH/port
    ./ETH/port/: stm32f4x7_eth_conf.h stm32f4x7_eth_conf_template.h
  group FreeRTOS/src
    ./FreeRTOS/src/: tasks.c queue.c list.c timers.c event_groups.c
  group FreeRTOS/inc
    ./FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stack_macros.h stream_buffer.h task.h timers.h
  group FreeRTOS/port
    ./FreeRTOS/port/: FreeRTOSConfig.h freertos_hooks.c heap_4.c port.c portmacro.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:FSMC 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
