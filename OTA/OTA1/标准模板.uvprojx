# Keil uVision project 标准模板.uvprojx, settings and files
target gpio标准库 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 标准模板 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000, SYS_TEST_BOARD=1
  c include: .\FWLIB\inc;.\FreeRTOS\inc;.\FreeRTOS\port;.\ETH\inc;.\ETH\port;.\ota
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xC000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --muldefweak --diag_suppress=L6439W
  group user
    ./: main.c
  group Src
    ./FWLIB/src/: beep.c ext_io.c gpio_core.c delay.c key.c led.c lcd.c sys_adc.c sys_clock.c sys_dma.c sys_eth.c sys_fault.c sys_flash.c sys_exti.c sys_i2c.c sys_nvic.c sys_pwr.c sys_spi.c sys_tick.c sys_tim.c sys_usart.c lora_e22.c sys_wdg.c sys_oled.c sys_mpu6050.c sys_dht11.c sys_bh1750.c sys_bmp280.c sys_ccs811.c sys_rs485.c sys_modbus.c sys_frame.c sys_str.c sys_rtc.c sys_softimer.c
  group Inc
    ./FWLIB/inc/: gpio_core.h delay.h led.h lcd.h key.h beep.h ext_io.h sys_clock.h sys_tick.h sys_usart.h lora_e22.h sys_tim.h sys_exti.h sys_pwr.h sys_nvic.h sys_dma.h sys_eth.h sys_fault.h sys_flash.h sys_i2c.h sys_spi.h sys_adc.h sys_wdg.h sys_oled.h sys_mpu6050.h sys_dht11.h sys_bh1750.h sys_bmp280.h sys_ccs811.h sys_rs485.h sys_modbus.h sys_frame.h sys_str.h sys_rtc.h sys_softimer.h sys_bitband.h
  group ETH/src
    ./ETH/src/: stm32f4x7_eth.c
  group ETH/inc
    ./ETH/inc/: stm32f4x7_eth.h
  group ETH/port
    ./ETH/port/: stm32f4x7_eth_conf.h stm32f4x7_eth_conf_template.h
  group FreeRTOS/src
    ./FreeRTOS/src/: tasks.c queue.c list.c timers.c event_groups.c
  group FreeRTOS/inc
    ./FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stack_macros.h stream_buffer.h task.h timers.h
  group FreeRTOS/port
    ./FreeRTOS/port/: FreeRTOSConfig.h freertos_hooks.c heap_4.c port.c portmacro.h
  group ota
    ./ota/: ota_crc16.c ota_app.c esp8266_at.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
