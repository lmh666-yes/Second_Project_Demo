# Keil uVision project OTA1_Boot.uvprojx, settings and files
target OTA_Boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x8000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OTA1_Boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, HSE_VALUE=8000000
  c include: .;..\OTA1\ota;E:\k5_v5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --muldefweak --diag_suppress=L6439W
  group boot
    ./: boot_main.c ota_image.c boot_flash.c boot_uart.c
    ../OTA1/ota/: ota_crc16.c
  group Device
    ../OTA1/RTE/Device/STM32F407ZE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
